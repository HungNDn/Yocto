FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://example.patch;striplevel=0"
