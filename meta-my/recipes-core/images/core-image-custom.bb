DESCRIPTION = "My Custom Image for Raspberry Pi"
LICENSE = "MIT"

inherit core-image

IMAGE_INSTALL += "packagegroup-myapps"



