IMAGE_INSTALL_append = " example"